# Keil uVision project TG6A.uvprojx, settings and files
target TG6A-APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32L406RB Nationstech
  pack: Nationstech.N32L40x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XHT-13S3P-01-0x +hex
  AfterMake: fromelf --bin --output=.\bin\@L.bin "#L"
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\core;..\CMSIS\device;..\n32l40x_std_periph_driver\inc;..\BMS;..\BMS\AFE\kc81710h;..\BMS\MCU
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Startup
    ../CMSIS/device/startup/: startup_n32l40x.s
  group Cmsis
    ../CMSIS/device/: system_n32l40x.c
  group Library
    ../n32l40x_std_periph_driver/src/: misc.c n32l40x_adc.c n32l40x_comp.c n32l40x_crc.c n32l40x_dbg.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_lptim.c n32l40x_lpuart.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_tim.c n32l40x_usart.c n32l40x_opamp.c n32l40x_spi.c n32l40x_can.c
  group MCU
    ../BMS/MCU/: McuHal_N32L40X.c n32l40x_it.c
  group AFE
    ../BMS/AFE/kc81710h/: AfeModule.c kc81710h.c
  group BMS
    ../BMS/: Balance.c BatterCheck.c Calib.c Charge.c DataFlash.c DisCharge.c GotoBoot.c interface.c key.c Main.C PowerCtrl.C soc.c UartBW.c BmsCtrl.c CanBW.c AND_CAN_Protocol.c queue.c multiCan.c candrv.c CanOtaSL.c CanUpgradeBW.c SoftWareCRC.c
