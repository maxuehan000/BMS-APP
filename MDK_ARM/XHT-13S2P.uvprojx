# Keil uVision project XHT-13S2P.uvprojx, settings and files
target N32G455 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G455REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.6
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XHT-NEXO-13S2P +hex
  AfterMake: fromelf --bincombined "!L" --output="$L\@L.bin"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER
  c include: ..\Source\CMSIS\core;..\Source\CMSIS\device;..\Source\n32g45x_algo_lib\inc;..\Source\n32g45x_std_periph_driver\inc;..\Source\BMS;..\Source\BMS\MCU;..\Source\BMS\AFE\kc81710h;..\Source\BMS\AFE
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Startup
    ../Source/CMSIS/device/startup/: startup_n32g45x.s
  group Cmsis
    ../Source/CMSIS/device/: system_n32g45x.c
  group Library
    ../Source/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_usart.c n32g45x_wwdg.c
  group MCU
    ../Source/BMS/MCU/: McuHal_N32G45X.c n32g45x_it.c
  group AFE
    ../Source/BMS/AFE/kc81710h/: AfeModule.c kc81710h.c
  group BMS
    ../Source/BMS/: AND_CAN_Protocol.c Balance.c BatterCheck.c BmsCtrl.c Calib.c CanBW.c candrv.c CanOtaSL.c CanUpgradeBW.c Charge.c DataFlash.c DisCharge.c GotoBoot.c interface.c key.c Main.c multiCan.c PowerCtrl.c queue.c soc.c SoftWareCRC.c UartBW.c AdcM.c RGB.c
